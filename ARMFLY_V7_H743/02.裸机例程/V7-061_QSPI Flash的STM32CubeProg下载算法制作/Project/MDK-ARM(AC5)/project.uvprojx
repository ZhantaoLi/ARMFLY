# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ARMFLY_STM32H7x_QSPI_W25Q256 +hex
  AfterMake: cmd.exe /C copy "!L" "..\@L.stldr"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FLASH_MEM,USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ../../User/: Loader_Src.c
  group Device Description
    ../../User/: Dev_Inf.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h
    ../../User/bsp/src/: bsp_qspi_w25q256.c
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_qspi.c stm32h7xx_hal_cortex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
