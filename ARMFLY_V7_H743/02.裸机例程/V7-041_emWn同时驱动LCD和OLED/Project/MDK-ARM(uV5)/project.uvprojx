# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\fonts;..\..\emWin\Include;..\..\emWin\Config;..\..\emWin\emWinTask;..\..\emWin\emWinDemo;..\..\emWin\JPEGConf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_fmc_sdram.c bsp_fmc_oled.c bsp_i2c_gpio.c bsp_i2c_eeprom_24xx.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_jpeg.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group GUI/Driver
    ../../User/bsp/src/: bsp_tft_h7.c bsp_tft_lcd.c bsp_ts_touch.c bsp_ts_ft5x06.c bsp_ts_gt911.c bsp_ts_gt811.c bsp_ts_stmpe811.c
  group GUI/GUI_X
    ../../emWin/GUI_X/: GUI_X.c
  group GUI/Config
    ../../emWin/Config/: GUIConf.c GUIConf.h LCDConf_Lin_Template.c LCDConf_Lin_Template.h
    ../../emWin/DisplayDriver/: GUIDRV_Template.c
  group GUI/Demo
    ../../emWin/emWinTask/: MainTask.c MainTask.h App_OLEDDlg.c
  group GUI/JPEG
    ../../emWin/JPEGConf/: JPEGConf.c JPEGConf.h decode_dma.c decode_dma.h
  group GUI/Lib
    ../../emWin/GUILib/: STemWin_CM7_wc16_ot_ARGB.a
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
