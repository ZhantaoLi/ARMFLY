# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx; ARM_MATH_LOOPUNROLL
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include; ..\..\Libraries\STM32H7xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\User\segger\RTT Viewer\RTT; ..\..\Libraries\CMSIS\DSP\PrivateInclude; ..\..\User\fft\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_fmc_io.c bsp_key.c bsp_led.c bsp_timer.c bsp_uart_esp8266.c bsp_uart_fifo.c bsp_user_lib.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group CMSIS/DSP
    ../../Libraries/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../Libraries/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../Libraries/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../Libraries/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../Libraries/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../Libraries/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group DSP_FFT
    ../../User/fft/src/asm/iar/: cr4_fft_1024_stm32.s cr4_fft_256_stm32.s cr4_fft_64_stm32.s
    ../../User/fft/src/: fft.c
    ../../User/fft/inc/: FFTInc.h stm32_dsp.h table_fft.h
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group User
    ../../User/: main.c
