# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_LOOPUNROLL
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\DSP\PrivateInclude;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\segger\RTT Viewer\RTT;..\..\User\fft\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_led.c bsp_dwt.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_uart_fifo.c bsp_tim_pwm.c bsp_user_lib.c bsp_uart_esp8266.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group CMSIS/DSP
    ../../Libraries/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../Libraries/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../Libraries/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../Libraries/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../Libraries/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../Libraries/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../Libraries/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
    ../../Libraries/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
  group DSP_FFT
    ../../User/fft/src/: fft.c
    ../../User/fft/inc/: FFTInc.h table_fft.h stm32_dsp.h
    ../../User/fft/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
