# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OUTPUT +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx,USE_FULL_LL_DRIVER
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_HAL_Driver\Inc;..\..\Libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\segger\RTT\RTT;..\..\User\lcd\inc;..\..\User\fonts
  library: MicroLIB
  memory RVCT1: ROM 0xc0000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep=gb2312.o
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_beep.c bsp_timer.c bsp_uart_fifo.c bsp_user_lib.c bsp_tim_pwm.c bsp_spi_bus.c bsp_spi_flash.c bsp_i2c_gpio.c bsp_eeprom_24xx.c
    ../../User/lcd/src/: bsp_gt811.c bsp_gt911.c bsp_tft_lcd.c bsp_tft_port.c bsp_ts_touch.c bsp_ts_ft5x06.c bsp_ts_stmpe811.c LCD_RA8875.c bsp_ra8875_port.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group HAL_Driver
    ../../User/bsp/: stm32f4xx_hal_conf.h
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c fonts.h hz12.c hz16.c hz24.c hz32.c gb2312.c asc62x40.c asc96x40.c ra8875_asc_width.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
