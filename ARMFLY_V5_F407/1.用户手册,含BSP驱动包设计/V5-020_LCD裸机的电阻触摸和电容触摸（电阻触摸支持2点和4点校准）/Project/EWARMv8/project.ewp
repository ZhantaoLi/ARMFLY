# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\User\segger\RTT\RTT; ..\..\User\lcd\inc; ..\..\User\fonts
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c
    ../../User/bsp/src/: bsp_beep.c bsp_eeprom_24xx.c bsp_i2c_gpio.c bsp_key.c bsp_led.c bsp_spi_bus.c bsp_spi_flash.c bsp_tim_pwm.c bsp_timer.c bsp_uart_fifo.c
    ../../User/lcd/src/: bsp_gt811.c bsp_gt911.c bsp_ra8875_port.c bsp_tft_lcd.c bsp_tft_port.c bsp_ts_ft5x06.c bsp_ts_stmpe811.c bsp_ts_touch.c LCD_RA8875.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c asc62x40.c asc96x40.c fonts.h gb2312.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c
  group HAL_Driver
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group User
    ../../User/: main.c
