# IAR project project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_FULL_LL_DRIVER; ARM_MATH_LOOPUNROLL
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS; ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_HAL_Driver\Inc; ..\..\User\bsp\inc; ..\..\User; ..\..\User\bsp; ..\..\Libraries\CMSIS\PrivateInclude; ..\..\User\segger\RTT Viewer\RTT; ..\..\User\fft\inc; ..\..\Libraries\CMSIS\Include1
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_esp8266.c bsp_uart_fifo.c bsp_user_lib.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group CMSIS/DSP
    ../../Libraries/CMSIS/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../Libraries/CMSIS/Source/CommonTables/: CommonTables.c
    ../../Libraries/CMSIS/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../Libraries/CMSIS/Source/ControllerFunctions/: ControllerFunctions.c
    ../../Libraries/CMSIS/Source/FastMathFunctions/: FastMathFunctions.c
    ../../Libraries/CMSIS/Source/FilteringFunctions/: FilteringFunctions.c
    ../../Libraries/CMSIS/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../Libraries/CMSIS/Source/MatrixFunctions/: MatrixFunctions.c
    ../../Libraries/CMSIS/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../Libraries/CMSIS/Source/SupportFunctions/: SupportFunctions.c
    ../../Libraries/CMSIS/Source/TransformFunctions/: TransformFunctions.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group DSP_FFT
    ../../User/fft/src/asm/iar/: cr4_fft_1024_stm32.s cr4_fft_256_stm32.s cr4_fft_64_stm32.s
    ../../User/fft/inc/: stm32_dsp.h table_fft.h
  group EWARMv8
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f407xx.s
  group HAL_Driver
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group MidFilter
    ../../User/: MidFilter.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerIAR/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group User
    ../../User/: main.c
