# Keil uVision project project.uvprojx, settings and files
target Flash (6140000::V6.14::ARMCLANG)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32F407xx,USE_FULL_LL_DRIVER,ARM_MATH_LOOPUNROLL
  c misc: -Wno-invalid-source-encoding
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Include1;..\..\Libraries\STM32F4xx_HAL_Driver\Inc;..\..\Libraries\STM32F4xx_HAL_Driver\Src\Legacy;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\segger\RTT Viewer\RTT;..\..\Libraries\CMSIS\PrivateInclude;..\..\User\fft\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f4xx_it.c
    ../../User/bsp/src/: bsp_key.c bsp_led.c bsp_timer.c bsp_uart_fifo.c bsp_user_lib.c bsp_uart_esp8266.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group HAL_Driver
    ../../User/bsp/: stm32f4xx_hal_conf.h
    ../../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group SEGGER/RTT
    ../../User/segger/RTT Viewer/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group CMSIS/DSP
    ../../Libraries/CMSIS/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../Libraries/CMSIS/Source/CommonTables/: CommonTables.c
    ../../Libraries/CMSIS/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../Libraries/CMSIS/Source/ControllerFunctions/: ControllerFunctions.c
    ../../Libraries/CMSIS/Source/FastMathFunctions/: FastMathFunctions.c
    ../../Libraries/CMSIS/Source/FilteringFunctions/: FilteringFunctions.c
    ../../Libraries/CMSIS/Source/MatrixFunctions/: MatrixFunctions.c
    ../../Libraries/CMSIS/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../Libraries/CMSIS/Source/SupportFunctions/: SupportFunctions.c
    ../../Libraries/CMSIS/Source/TransformFunctions/: TransformFunctions.c
    ../../Libraries/CMSIS/Source/InterpolationFunctions/: InterpolationFunctions.c
  group DSP_FFT
    ../../User/fft/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
    ../../User/fft/inc/: stm32_dsp.h table_fft.h
  group MidFilter
    ../../User/: MidFilter.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
